# Keil uVision project M0G3519_nortos_keil.uvprojx, settings and files
target M0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: M0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$Psyscfg.bat '$P' M0G3519.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../src,../src/app,../src/middle,../src/hardware,../src/MSPM0G3519_Library/zf_common,../src/MSPM0G3519_Library/zf_driver,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../src/: main.c
    ../: M0G3519.syscfg
    ./: startup_mspm0g351x_uvision.s
    ./: ti_msp_dl_config.h ti_msp_dl_config.c
  group Application
    ../src/app/: grayscale_app.c heartbeat_app.c imu_app.c motor_app.c oled_app.c power_app.c
  group Middle
    ../src/middle/: control_pid.c encoder.c grayscale.c heartbeat.c imu.c line_control.c motor.c oled.c power.c wheel_speed_control.c
  group Hardware
    ../src/hardware/: encoder_hw.c grayscale_hw.c heartbeat_hw.c imu_hw.c motor_hw.c oled_hw.c power_hw.c
  group SeekFree Library
    ../src/MSPM0G3519_Library/zf_common/: zf_common_clock.c zf_common_debug.c zf_common_fifo.c zf_common_font.c zf_common_interrupt.c
    ../src/MSPM0G3519_Library/zf_driver/: zf_driver_delay.c zf_driver_encoder.c zf_driver_gpio.c zf_driver_pwm.c zf_driver_timer.c zf_driver_uart.c zf_sdk_compat.c
